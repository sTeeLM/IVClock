# Keil uVision project IVClock.uvprojx, settings and files
target IVClock (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IVClock +hex
  BeforeMake: python gen_build_id.py ..\  ..\Core\Src\build_id.c
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --nodebug -v --output  IVClock\IVClock.bin IVClock\IVClock.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,IVCLOCK_BSP_USE_SOFT_I2C
  c include: ../Core/Inc;../System;../System/Console;../System/State Machine;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c debug.c delay.c cext.c stdio_ext.c build_id.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/: adc.c i2c.c iv18.c key.c tim.c usart.c acc.c blue_tooth.c mp3.c rom.c extint.c pwr.c ds3231.c bias.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/System
    ../System/: alarm.c beeper.c button.c clock.c config.c display.c player.c power.c timer.c console.c task.c sm.c ticks.c motion_sensor.c remote_control.c thermometer.c rtc.c ocv.c
  group Application/System/Console
    ../System/Console/: con_help.c con_clock.c con_motion_sensor.c con_power.c con_beeper.c con_display.c con_player.c con_alarm.c
  group Application/System/State Machine
    ../System/State Machine/: sm_clock_display.c sm_set_time.c sm_set_date.c sm_set_alarm.c sm_set_param.c sm_timer.c sm_stop_watch.c sm_common.c
software components: CMSIS:CORE 5.5.0
